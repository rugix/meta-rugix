RDEPENDS:${PN}:append:imx-nxp-bsp = "\
    kernel-modules \
    u-boot-default-env \
    u-boot-fw-utils \
"
