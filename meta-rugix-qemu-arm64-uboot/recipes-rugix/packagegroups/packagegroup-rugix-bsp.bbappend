RDEPENDS:${PN}:append:qemuarm64 = "\
    kernel-image \
    u-boot-default-env \
    u-boot-fw-utils \
"
