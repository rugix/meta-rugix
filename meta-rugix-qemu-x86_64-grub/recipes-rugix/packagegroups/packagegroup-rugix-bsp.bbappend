RDEPENDS:${PN}:append:qemux86-64 = "\
    kernel-image \
"
