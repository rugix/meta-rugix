require ${@bb.utils.contains('DISTRO_FEATURES', 'rugix', 'linux-yocto_rugix.inc', '', d)}
