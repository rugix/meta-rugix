DEFAULT_PREFERENCE = "-1"

SRCREV = "${AUTOREV}"

require rugix-bundler-native.inc
