SRCREV = "fa803e253ffe9d6d2ec5f267ec29b39b62f9e325"

require rugix-bundler-native.inc
