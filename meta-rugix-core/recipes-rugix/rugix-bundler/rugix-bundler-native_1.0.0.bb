SRCREV = "1a043d48639932903b80ea455cd9c073ea1828a6"

require rugix-bundler-native.inc
