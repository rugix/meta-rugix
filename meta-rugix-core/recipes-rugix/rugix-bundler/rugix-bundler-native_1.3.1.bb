SRCREV = "4fa2ed71b7a6a849e1955fb53bc61a359fe0f58e"

require rugix-bundler-native.inc
