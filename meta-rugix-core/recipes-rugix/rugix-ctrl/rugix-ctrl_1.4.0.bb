SRCREV = "6d7fc277919b0048893c80d7e1e6e488ddc7b27b"

require rugix-ctrl.inc
