SUMMARY = "Rugix core packages."
inherit packagegroup

RDEPENDS:${PN} = "rugix-ctrl"
