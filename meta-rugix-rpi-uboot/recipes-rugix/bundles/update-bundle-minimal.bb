inherit rugix-bundle

RUGIX_BUNDLE_PAYLOADS = "system"

RUGIX_PAYLOAD_system[image] = "core-image-minimal"
RUGIX_PAYLOAD_system[partition] = "2"
